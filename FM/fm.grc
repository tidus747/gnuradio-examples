options:
  parameters:
    author: Iván Rodríguez
    copyright: '2021'
    description: FM
    generate_options: qt_gui
    id: FM
    output_language: python
    title: FM
  states: {}

blocks:
- name: if_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    orient: Qt.Horizontal
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume In
    orient: Qt.Horizontal
    start: '0'
    step: '0.25'
    stop: '5'
    value: '1'
  states: {}
- name: volume_out
  id: variable_qtgui_range
  parameters:
    label: Volume Out
    orient: Qt.Horizontal
    start: '0'
    step: '0.25'
    stop: '5'
    value: '0.25'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.150'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters: {}
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    fh: '-1.0'
    max_dev: 75e3
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_out
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/irodrigu/Proyectos/sc-clases/2020-2021/P1/src/songs/Lofi.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Modulated
    name: Modulated
    size: '2048'
    srate: usrp_rate
    type: float
    ymax: '1.01'
    ymin: '0.99'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Demodulated
    label2: Original
    name: Demodulated
    nconnections: '2'
    size: '2048'
    srate: usrp_rate
    type: float
    update_time: '0.01'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
