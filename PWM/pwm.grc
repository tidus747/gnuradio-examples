options:
  parameters:
    author: Iván Rodríguez
    copyright: '2021'
    description: PWM
    generate_options: qt_gui
    id: PWM
    output_language: python
    title: PWM
  states: {}

blocks:
- name: carrier_lvl
  id: variable_qtgui_range
  parameters:
    label: Carrier Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: in_gain
  id: variable_qtgui_range
  parameters:
    label: Volumen IN
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '5'
    value: '0.2'
  states: {}
- name: out_gain
  id: variable_qtgui_range
  parameters:
    label: Volumen OUT
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '5'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: carrier_lvl
    freq: '60000'
    offset: '-(carrier_lvl)/2'
    phase: '1.5707'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: out_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: in_gain
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/irodrigu/Proyectos/sc-clases/2020-2021/P1/src/songs/Lofi.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Comparator',   # will show up in GRC\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n\n    def work(self, input_items, output_items):\n   \n        for i in range(len(input_items[0])):\n            if (input_items[0][i] < input_items[1][i]):\n                output_items[0][i] = 1\n            else:\n                output_items[0][i] = 0\n\n        return len(output_items[0])\n        \n"
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Modulated
    name: Modulated
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Demodulated
    label2: Original Signal
    name: Demodulated
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Original
    label2: Carrier
    name: Original signals
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', epy_block_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0_1, '0']
- [epy_block_0, '0', low_pass_filter_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
